# Keil uVision project Radon_Monitor.uvprojx, settings and files
target Radon_Monitor (6190000::V6.19::ARMCLANG)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F460.1.0.11
  cpu: IROM1(0x00000000,0x80000) IROM2(0x03000C00,0x3FC) IRAM1(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: Radon_Monitor +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=6 wLevel=3
  c define: __DEBUG,HC32F460,USE_DDL_DRIVER,
  c include: ..\Core\system;..\Drivers\HC32F460_Driver\include;..\Drivers\USER_Driver\include;..\Configs;..\Middlewares\freeRTOS\include;..\Middlewares\freeRTOS\portable\GCC\ARM_CM4F;..\Middlewares\qf_lib\include;..\MessageBus;..\Board_Support_Package\include;..\Application;..\Application\include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3c0
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
  group Startup
    ../Core/startup/: startup_hc32f460.s
  group System
    ../Core/system/: system_hc32f460.c
  group Driver/HC32F460_Driver
    ../Drivers/HC32F460_Driver/source/: hc32_ll.c hc32_ll_adc.c hc32_ll_aes.c hc32_ll_aos.c hc32_ll_can.c hc32_ll_clk.c hc32_ll_cmp.c hc32_ll_crc.c hc32_ll_dbgc.c hc32_ll_dcu.c hc32_ll_dma.c hc32_ll_efm.c hc32_ll_emb.c hc32_ll_event_port.c hc32_ll_fcg.c hc32_ll_fcm.c hc32_ll_gpio.c hc32_ll_hash.c hc32_ll_i2c.c hc32_ll_i2s.c hc32_ll_icg.c hc32_ll_interrupts.c hc32_ll_keyscan.c hc32_ll_mpu.c hc32_ll_ots.c hc32_ll_pwc.c hc32_ll_qspi.c hc32_ll_rmu.c hc32_ll_rtc.c hc32_ll_sdioc.c hc32_ll_spi.c hc32_ll_sram.c hc32_ll_swdt.c hc32_ll_tmr0.c hc32_ll_tmr4.c hc32_ll_tmr6.c hc32_ll_tmra.c hc32_ll_trng.c hc32_ll_usart.c hc32_ll_utility.c hc32_ll_wdt.c hc32f460_ll_interrupts_share.c
  group Driver/USER_Driver
    ../Drivers/USER_Driver/source/: 24cxx.c ev_hc32f460_lqfp100_v2.c ev_hc32f460_lqfp100_v2_24cxx.c ev_hc32f460_lqfp100_v2_w25qxx.c ev_hc32f460_lqfp100_v2_wm8731.c w25qxx.c wm8731.c usartDriver.cpp commonDriver.cpp
  group MessageBus
    ../MessageBus/: messageBus.cpp
  group Board_Support_Package
    ../Board_Support_Package/source/: cpuUtilization.c drvHal.c hal.c ledConfig.c keyConfig.c usart1Config.c beatTaskConfig.c
  group Application
    ../Application/source/: buttonControl.cpp commonControl.cpp messageBusProcessor.cpp uartProtocolProcessor.cpp usartTask.cpp
    ../Application/: taskFactory.c
  group Middlewares/FreeRTOS
    ../Middlewares/freeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/freeRTOS/portable/MemMang/: heap_4.c
    ../Middlewares/freeRTOS/portable/GCC/ARM_CM4F/: port.c
  group Middlewares/qf_lib
    ../Middlewares/qf_lib/source/: appManage.c beatTask.c bmp280.c button.c keyValueTransation.c ringBuffer.c wire.c
  group Config
    ../Configs/: globalConfig.c
  group Source
    ../Source/: main.cpp
